VERSION 5.8 ;
UNITS
 DATABASE MICRONS 1000 ;
END UNITS
LAYER abstract_metal1
 TYPE ROUTING ;
 DIRECTION HORIZONTAL ;
 PITCH 1 ;
 WIDTH 1 ;
 SPACING 1 ;
END abstract_metal1
END LIBRARY
